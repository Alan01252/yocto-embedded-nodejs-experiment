DESCRIPTION = "Install nodejs for ifu"
SECTION = "ifu"
LICENSE = "MIT"

DEPENDS += " node"
RDEPENDS_${PN} += " node"

